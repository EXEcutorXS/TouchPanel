# Keil uVision project StovePanel.uvprojx, settings and files
target GD32F303CC (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32F303CC GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.0.0
  cpu: IRAM(0x20000000,0x0C000) IROM(0x08000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: StovePanel_V2_2 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER  GD32F30x
  c misc: --cpp
  c include: .\User\Main;.\GD32F30x_SPL\Core;.\GD32F30x_SPL\Include;.\User\Stove;.\Drivers\Usart;.\User\Protocol_3;.\Drivers;.\User\Display;.\Drivers\LED_Driver
  memory RVCT4: ROM 0x8000000 size 0x37000
  memory RVCT9: RAM 0x20000000 size 0xbffc
  group Main
    ./User/Main/: main.cpp HeaterVars.cpp
    ./User/Stove/: Stove.cpp
    ./User/Protocol_3/: protocol_3.cpp
    ./User/Display/: Display.cpp
  group Drivers
    ./Drivers/Usart/: usart.cpp
    ./Drivers/: Buzzer.cpp CapSensor.cpp core.cpp LedLine.cpp
    ./Drivers/LED_Driver/: LedDriver.cpp
  group GD32F30x_SPL
    ./GD32F30x_SPL/Source/: gd32f30x_adc.c gd32f30x_bkp.c gd32f30x_can.c gd32f30x_crc.c gd32f30x_ctc.c gd32f30x_dac.c gd32f30x_dbg.c gd32f30x_dma.c gd32f30x_enet.c gd32f30x_exmc.c gd32f30x_exti.c gd32f30x_fmc.c gd32f30x_fwdgt.c gd32f30x_gpio.c gd32f30x_misc.c gd32f30x_pmu.c gd32f30x_rcu.c gd32f30x_rtc.c gd32f30x_sdio.c gd32f30x_spi.c gd32f30x_timer.c gd32f30x_usart.c gd32f30x_wwdgt.c
    ./GD32F30x_SPL/Core/: startup_gd32f30x_hd.s system_gd32f30x.c
target STM32F091 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: GD32F303CC GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.0.0
  cpu: as above
  output: 28-0-32-1_Integral +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER USE_SLEEP_MODE_NO STM32F0xx
  c misc: --cpp
  c include: .\User\Main;.\Library\Param_Tools;.\Library\Fan;.\Library\GlowPlug;.\Library\FuelPump;.\Library\WarmingUp;.\Library\FuelPump;.\Library\Recorder;.\Library\CorrectMode;.\Library\Engine;.\Library\Protocol_4;.\Library\Pump;.\Library\Relay;.\Library\Signaling;.\Library\Usart_4;.\Library\PMU;.\Library\Flame14TC;.\Library\PU-4;.\Library\ADCmodule;.\GD32F30x_SPL\Core;.\GD32F30x_SPL\Include;.\Library\Can;.\Library\Press_spi;.\Library\Usart;.\Library\Protocol_3
  memory RVCT4: ROM 0x8008000 size 0x37000
  memory RVCT9: RAM 0x20000000 size 0xbffc
